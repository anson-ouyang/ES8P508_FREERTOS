# Keil uVision project ES_FREERTOS.uvproj, settings and files
target ES_FREERTOS (ARM-ADS)
  device: ES8P508xFLXX ES
  cpu: IRAM(0x20000000-0x20005FFF)  IROM(0x00000000-0x0001FFFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: ES_FREERTOS +hex
  c flags: Optim=1
  c include: ..\driver\inc;..\mcu;..\midware\FreeRTOS;..\midware\FreeRTOS\Source\include;..\midware\FreeRTOS\Source\portable\Keil\ARM_CM0;..\midware\FreeRTOS\Source\portable\MemMang;..\pa;..\usr
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group driver
    ../driver/src/: lib_adc.c lib_aes.c lib_crc.c lib_flashiap.c lib_gpio.c lib_iap.c lib_iic.c lib_printf.c lib_rtc.c lib_scs.c lib_scu.c lib_spi.c lib_timer.c lib_uart.c lib_wdt.c
  group freertos
    ../midware/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../midware/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../midware/FreeRTOS/Source/portable/Keil/ARM_CM0/: port.c
  group usr
    ../usr/: main.c startup_ES8P508x.s
  group PA
    ../pa/: pa_freertos.c
  group MCU
    ../mcu/: system_ES8P508x.c irqhandler.c
